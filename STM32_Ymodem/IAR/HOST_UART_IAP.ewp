# IAR project HOST_UART_IAP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Source_Packages\main; ..\Source_Packages\APP; ..\Source_Packages\driver; ..\Source_Packages\STM32_lib\CMSIS\CM3; ..\Source_Packages\STM32_lib\CMSIS\startup; ..\Source_Packages\STM32_lib\CMSIS\startup\iar; ..\Source_Packages\STM32_lib\STM32F10x_standard_firmware_lib\src; ..\Source_Packages\STM32_lib\STM32F10x_standard_firmware_lib\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HOST_UART_IAP.bin
  ILINK.IlinkOutputFile: HOST_UART_IAP.out
  ILINK.IlinkIcfFile: ..\icf\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../Source_Packages/APP/: HOST.c HOST.h Ymodem.c Ymodem.h
  group driver
    ../Source_Packages/driver/: BSP.c BSP.h Pin.c Pin.h UART_Drv.c UART_Drv.h
  group main
    ../Source_Packages/main/: all_header_file.h def_and_type.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group readme
    ../Source_Packages/readme/: readme.txt
  group STM32_lib/CMSIS
    ../Source_Packages/STM32_lib/CMSIS/CM3/: core_cm3.h
  group STM32_lib/firmware_lib
    ../Source_Packages/STM32_lib/STM32F10x_standard_firmware_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_lib/statrup
    ../Source_Packages/STM32_lib/CMSIS/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../Source_Packages/STM32_lib/CMSIS/startup/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
