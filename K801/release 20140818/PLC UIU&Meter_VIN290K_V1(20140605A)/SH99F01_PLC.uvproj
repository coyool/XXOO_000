# Keil uVision project SH99F01_PLC.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH99F01 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0-0x1FF) CLOCK(12000000)
  output: SH99F01_PLC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c UART.c PLT.c ISR.c APP.c SSP.c
