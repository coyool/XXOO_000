# IAR project 01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\source_code\cmsis; ..\source_code\cmsis_boot; ..\source_code\STM32F10x_StdPeriph_Lib\inc; ..\source_code\STM32F10x_StdPeriph_Lib\src; ..\source_code\BSP; ..\source_code\APP; ..\source_code\user; ..\source_code\STduino; ..\source_code\shield\RF\A7139; ..\source_code\OpenSource_Lib\FEC; ..\source_code\OpenSource_Lib\CRC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 01.bin
  ILINK.IlinkOutputFile: 01.out
  ILINK.IlinkIcfFile: E:\Git_repository\Embedded_Pi\source_code\cmsis_boot\01.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Note/: CodeTemplates_V1.0.ENU.txt
    ../source_code/: LICENSE.txt
  group APP
    ../source_code/APP/: loop.c loop.h RF.c RF.h
  group BSP
    ../source_code/BSP/: BSP.c BSP.h delay.c delay.h EXTI.c EXTI.h LED.c LED.h
  group cmsis
    ../source_code/cmsis/: core_cm3.h
  group cmsis_boot
    ../source_code/cmsis_boot/: startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group OpenSource_Lib/CRC
    ../source_code/OpenSource_Lib/CRC/: CRC.c CRC.h
  group OpenSource_Lib/FEC
    ../source_code/OpenSource_Lib/FEC/: 01.c FEC.c FEC.h FECDec.c FECDec.h FECEnc.c
  group shield/RF/A7139
    ../source_code/shield/RF/A7139/: A7139.c A7139.h A7139_config.c A7139_config.h A7139_RF.c A7139_RF.h A7139_RFreg.h A7139_RFregsetting.c A7139_RFregsetting.h
  group STduino
    ../source_code/STduino/: Digital_IO.c Digital_IO.h Interrupts.c Interrupts.h Serial.c Serial.h
  group STM32F10x_StdPeriph_Lib/inc
    ../source_code/STM32F10x_StdPeriph_Lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32F10x_StdPeriph_Lib/src
    ../source_code/STM32F10x_StdPeriph_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../source_code/user/: all_header_file.h def_and_type.h main.c main.h
