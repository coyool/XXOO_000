# IAR project boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9AFA32N Fujitsu MB9AFA32N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\boot; ..\BSP; ..\common; ..\driver; ..\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: boot.bin
  ILINK.IlinkOutputFile: MB9BF218S.out
  ILINK.IlinkIcfFile: boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group BOOT
    ../boot/: boot.c boot.h Ymodem.c Ymodem.h Ymodem_CRC16.c Ymodem_CRC16.h
  group BSP
    ../BSP/: flash.c flash.h LED.c LED.h UART_Drv.c UART_Drv.h
  group common
    ./: startup_mb9xfxxx.s
    ../common/: system_mb9xfxxx.c
  group driver
    ../driver/flash/: mainflash_fm3.c
    ../driver/mfs/: mfs_fm3.c
    ../driver/mfs/uart/: uart_fm3.c
    ../driver/wd/: wd_fm3.c
  group user
    ../user/: all_header_file.h debug.h def_and_type.h main.c pdl_user.h resource.h
