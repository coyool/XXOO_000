# IAR project boot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9AFA32N Fujitsu MB9AFA32N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\boot; ..\BSP; ..\common; ..\driver; ..\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ST-DU01.bin
  ILINK.IlinkOutputFile: MB9BF218S.out
  ILINK.IlinkIcfFile: boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../NOTE/: CodeTemplates_V1.0.ENU.txt
  group BOOT
    ../boot/: IAP.c IAP.h IEC_21.c IEC_21.H Ymodem.c Ymodem.h
  group BSP
    ../BSP/: button.c button.h BUZZ.C Drv_WD.c Drv_WD.h LED.c LED.h MX25L3206E.c UART_Drv.c UART_Drv.h
  group common
    ./: startup_mb9xfxxx.s
    ../common/: system_mb9xfxxx.c
  group driver
    ../driver/io/: io_fm3.c
    ../driver/flash/: mainflash_fm3.c
    ../driver/mfs/: mfs_fm3.c
    ../driver/mfs/uart/: uart_fm3.c
  group user
    ../user/: all_header_file.h debug.h def_and_type.h main.c pdl_user.h resource.h
