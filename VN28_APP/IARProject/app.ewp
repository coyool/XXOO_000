# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9AFA32N Fujitsu MB9AFA32N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\app; ..\common; ..\driver; ..\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.bin
  ILINK.IlinkOutputFile: MB9BF218S.out
  ILINK.IlinkIcfFile: app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: delay.c delay.h flash.c flash.h UserLed.c UserLed.h
  group common
    ./: startup_mb9xfxxx.s
    ../common/: system_mb9xfxxx.c
  group driver
    ../driver/clock/: clock_fm3.c
    ../driver/io/: io_fm3.c
    ../driver/flash/: mainflash_fm3.c
  group user
    ../user/: debug.h main.c pdl_user.h resource.h
