# Keil uVision project loader.uvproj, settings and files
target loader (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: loader +hex
  AfterMake: D:\应用软件\keil4\ARM\BIN40\fromelf.exe
  c flags: Optim=3
  c include: ..\FWlib\inc;..\project;..\CMSIS;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: loader.sct
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_tim.c
  group app
    ../APP/: main.c W25X64.c crc.c iap.c flash.c iapcmd.c switch.c uart.c ymodem.c
