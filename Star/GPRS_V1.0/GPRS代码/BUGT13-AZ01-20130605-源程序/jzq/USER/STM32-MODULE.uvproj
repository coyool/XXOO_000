# Keil uVision project STM32-MODULE.uvproj, settings and files
target jzq (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ASBJ-MODULE +hex
  BeforeMake: E:\工作用盘\伊朗GPRS_ybz\GPRS代码\BUGT13-AZ01-20130605-源程序\jzq\USER\r.bat
  AfterMake: D:\应用软件\keil4\ARM\BIN40\fromelf.exe
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,METER_MODULE
  c misc: --C99 --GNU
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\APP;..\BSP;..\uCOS-II\Ports;..\uCOS-II\Source;..\platform;..\HAL;..\application
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: BSP.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group platform
    ../platform/gprs/: GprsCtrl.c m35gprs.c plat_gprs.c mc55gprs.c
    ../platform/sys/: time.c sleep.c mutex.c timer.c event.c network.c platpara.c task.c
    ../platform/debug/: log.c shell.c ttyshell.c shellcmds.c ymodem.c
    ../platform/lib/: fun.c Ring.c
    ../platform/driver/: plat_init.c rs485.c
    ../platform/plc/: plc_rsc_std.c plc_3762.c dl645_1997.c plcomm.c amrplat.c dd645_2007.c
  group HAL
    ../HAL/: usart.c rtc.c rx8025.c switch.c flash.c mx25l64.c W25X64.c ds3231.c stm32rtc.c
  group application
    ../application/uplink/: ctrlcmd.c ir.c keepalive.c svrcomm.c svrmsg.c tranfile.c uplink_buffer.c uplink_dl.c up485.c hdlc.c terminfo.c
    ../platform/plc/: app_proto.c
    ../application/lib/: bcd.c align.c crc.c
    ../application/uplink/gprs/: gprs_dev.c gprs_task.c
    ../application/param/: meter.c operation.c param_init.c term.c unique.c datatask.c
    ../application/monitor/: runstate.c alarm.c
    ../application/sys/syscall/: reset.c syscall_init.c
    ../application/sys/storage/: store_iap.c flashsave.c store_para.c store_alarm.c
    ../application/: appmain.c
    ../application/sys/: sys_init.c
    ../application/cenmet/: cenmet_dlms.c
