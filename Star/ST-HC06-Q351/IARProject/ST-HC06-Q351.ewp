# IAR project ST-HC06-Q351.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430FE427 MSP430FE427
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\Source_code\Ueser; ..\Source_code\RF; ..\Source_code\Serial
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FE427.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group RF
    ../Source_code/RF/: RF.c RF.h RF_regConfig.c RF_regConfig.h RF_SPI.c RF_SPI.h
  group Serial
    ../Source_code/Serial/: Serial.c Serial.h
  group User
    ../Source_code/User/: all_header_file.h def_and_type.h ISR.c main.c main.h
