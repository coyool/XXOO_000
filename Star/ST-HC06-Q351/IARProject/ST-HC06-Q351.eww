<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ST-HC06-Q351.ewp</path>
  </project>
  <batchBuild/>
</workspace>


