# IAR project BUZT13-01CN.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_ASSERT; INIT_SYSCLK_AT_BOOTING
  ICCARM.CCIncludePath2: ..\Source_code\Library\CMSIS\Include; ..\Source_code\Library\Device\Nuvoton\M051Series\Source; ..\Source_code\Library\Device\Nuvoton\M051Series\Include; ..\Source_code\Library\Device\Nuvoton\M051Series\Source\IAR; ..\Source_code\Library\StdDriver\src; ..\Source_code\Library\StdDriver\inc; ..\Source_code\BSP; ..\Source_code\APP; ..\Source_code\API; ..\Source_code\User; ..\Source_code\Arduino; ..\Source_code\Shield\Display\LED; ..\Source_code\OpenSource_Lib\FEC; ..\source_code\OpenSource_Lib\CRC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BUZT13-01CN.srec
  ILINK.IlinkOutputFile: BUZT13-01CN.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Note/: CodeTemplates_V1.0.ENU.txt
  group Arduino
    ../Source_code/Arduino/: Arduino.h Digital_IO.c Digital_IO.h Serial.c Serial.h Time.c Time.h
  group Library/M051Series
    ../Source_code/Library/Device/Nuvoton/M051Series/Include/: M051Series.h system_M051Series.h
    ../Source_code/Library/Device/Nuvoton/M051Series/Source/IAR/: startup_M051Series.s
    ../Source_code/Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group Library/StdDriver
    ../Source_code/Library/StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group OpenSource_Lib/CRC
    ../Source_code/OpenSource_Lib/CRC/: CRC.c
    ../source_code/OpenSource_Lib/CRC/: CRC.h
  group OpenSource_Lib/FEC
    ../Source_code/OpenSource_Lib/FEC/: FEC.c FEC.h Hamming.c Hamming.h
  group Shield/Display
    ../Source_code/Shield/Display/LED/: LED.c LED.h
  group User
    ../Source_code/User/: all_header_file.h def_and_type.h main.c main.h
