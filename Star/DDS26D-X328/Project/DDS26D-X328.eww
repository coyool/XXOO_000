<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DDS26D-X328.ewp</path>
  </project>
  <batchBuild/>
</workspace>


