# IAR project DDS26D-X328.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9AFA32N Fujitsu MB9AFA32N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\user; ..\app; ..\driver; ..\target; ..\target\common; ..\protocol; ..\RF
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DDS26D-X328-20140924.bin
  ILINK.IlinkOutputFile: DDS26D-X328.out
  ILINK.IlinkIcfFile: DDS26D-X328.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../doc/: CodeTemplates_V1.0.ENU.txt
  group App
    ../app/: APP_Api.c Billing.c Clock.c display.c DL645_07.c DLMS_AES.c Energy.c Event.c Freeze.c IEC62056-21.c Log.c MeterInfo.c NvmOperation.c ProtocolManage.c Public.c
  group Driver
    ../driver/: Drv_ADC.c Drv_ATT7059.c Drv_BT.c Drv_Calibrate.c Drv_IO.c Drv_LCD.c drv_Led.c Drv_RTC.c Drv_RTCcal.c Drv_RTCSecPulse.c drv_uart.c Drv_WD.c Eeprom.c IIC.c key.c PowerManage.c Screen.c TempSample.c
  group RF
    ../RF/: Drv_RF.c Drv_SPI.c RF.c RF.h RF_link.c RF_link.h RF_regConfig.c RF_regConfig.h RF_SPI.c RF_SPI.h RFData.c RFData.h RfModel.c RfModel.h
  group Target
    ../target/adc/: adc12_fm3.c
    ../target/bt/: bt_fm3.c
    ../target/clock/: clock_fm3.c
    ../target/extint/: extint_fm3.c
    ../target/: interrupt.c
    ../target/io/: io_fm3.c
    ../target/lcdc/: lcdc_fm3.c
    ../target/lpcm/: lpcm_fm3.c
    ../target/lvd/: lvd_fm3.c
    ../target/flash/: mainflash_fm3.c
    ../target/mfs/: mfs_fm3.c
    ../target/mft/: mft_adcmp_fm3.c mft_frt_fm3.c
    ../target/reset/: reset_fm3.c
    ../target/rtc/: rtc_fm3.c
    ../target/common/: startup_mb9xfxxx.s system_mb9xfxxx.c
    ../target/mfs/uart/: uart_fm3.c
    ../target/wd/: wd_fm3.c
  group User
    ../user/: main.c task.c
